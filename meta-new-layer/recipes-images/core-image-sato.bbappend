IMAGE_INSTALL_append = " new-layer "
