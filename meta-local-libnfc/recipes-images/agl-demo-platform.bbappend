IMAGE_INSTALL_append = " \ 
						local-libnfc \
						i2c-tools \
					   "
